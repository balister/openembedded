require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "2912c1c7cde099f2671f2f8f24879b82"
SRC_URI[sha256sum] = "6c3c70158e74754f29d9709a7668eff6238a5cd5bf31e35b31bbeaaee74dca7c"

