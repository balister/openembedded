require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "414dfbb922ab40d62dbbe0f918abf6a1"
SRC_URI[sha256sum] = "e191b11f414b754d7de3bda46e0d2c217727da8cb7bfa430c98790b23ef7fa2f"

