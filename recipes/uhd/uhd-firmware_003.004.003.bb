require recipes/uhd/uhd-firmware.inc

S = "${WORKDIR}/uhd-images_${PV}-release"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "f9ba13a169d399bccd3143786657d42f"
SRC_URI[sha256sum] = "74508ee437d69b93858f31a52ea43276c0a8be53b0169374acbb7679ac3f249c"

