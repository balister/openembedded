require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c92809b7486447d3e249bbea7ee2d1f0"
SRC_URI[sha256sum] = "9b994c392f76d309d7f274169ea9df3709c58630dc49f04922810001526165df"

